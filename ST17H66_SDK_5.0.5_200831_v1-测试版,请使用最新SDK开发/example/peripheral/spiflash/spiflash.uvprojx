# Keil uVision project spiflash.uvprojx, settings and files
target spiflash (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: spiflash +hex
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/spiflash.axf
  AfterMake: fromelf.exe .\Objects\spiflash.axf --i32combined --output .\bin\spiflash.hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CFG_CP   CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEBUG_INFO=1 PHY_MCU_TYPE=MCU_BUMBEE_M0 DMAC_USE=1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\hrs;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\adc;..\..\..\components\driver\clock;..\..\..\components\driver\spiflash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\kscan;..\..\..\lib;.\Source;..\..\..\components\ble\controller;..\..\..\components\arch\cm0;..\..\..\misc;..\..\..\components\driver\dma;..\..\..\components\driver\flash
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: spiflash_demo.c OSAL_spiflash.c spiflash_Main.c
  group driver
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/spiflash/: spiflash.c
    ../../../components/driver/spi/: spi.c
    ../../../components/driver/dma/: dma.c
    ../../../components/driver/flash/: flash.c
  group rf
    ../../../lib/: rf.lib
  group ::Device
    RTE/Device/ARMCM0/: startup_ARMCM0.s system_ARMCM0.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
